# Keil uVision project ZD1600.uvproj, settings and files
target ZD1600 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ZD1600
  c flags: wLevel=2
  c define: LBP_DBG
  c include: ..\cfg;..\ucgui\uCGUI_Config;..\ucgui\uCGui_Source\Core;..\ucos-ii\kernel;..\ucos-ii\Ports\ARM-Cortex-M3\Generic\RealView
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT6: RAM 0x68000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ZD1600.sct
  group cfg
    ../cfg/: app_cfg.h os_cfg.h stm32f10x_conf.h
  group boot
    ../stm32lib/src/: cortexm3_macro.s
    ../boot/: stm32f10x_it.c stm32f10x_vector.s
  group ucos-ii/port
    ../ucos-ii/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ucos-ii/kernel
    ../ucos-ii/kernel/: ucos_ii.c
  group stm32lib
    ../stm32lib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_dac.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_spi.c
  group drivers
    ../drives/: led.c keys.c aux_lib.c adc.c rtc.c tmr_drv.c drv_init.c gpio.c uart_drv.c mystring.c retarget.c
  group app
    ../app/: main.c com_init.c monitor.c App_led.c App_Hook.c test.c
