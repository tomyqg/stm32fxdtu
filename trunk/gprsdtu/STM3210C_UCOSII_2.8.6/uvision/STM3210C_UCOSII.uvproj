# Keil uVision project STM3210C_UCOSII.uvproj, settings and files
target STM3210C_UCOSII (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C_UCOSII
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\Code\UC_OSII\core;..\Code\UC_OSII\ports;..\Code\Libraries\CMSIS\Core\CM3;..\Code\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Code\Utilities;..\Code\Utilities\STM3210C_EVAL;..\Code\User\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Code/Startup/: STM32F10x.s
  group CMSIS
    ../Code/Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group ST_Lib
    ../Code/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c
    ../Code/Utilities/: stm32_eval.c
  group uCOS_Core
    ../Code/UC_OSII/core/: os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS_Ports
    ../Code/UC_OSII/ports/: os_cpu_a.asm os_cpu_c.c
  group User
    ../Code/User/src/: main.c stm32f10x_it.c mystring.c
  group Readme
    ../Code/Readme/: Readme.txt
  group Driver
    ../Code/Driver/: gprsmodule.c
